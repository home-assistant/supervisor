
CONNECTIVITY_PACKAGES_remove = "openvpn"
