
RDEPENDS_${PN}.remove = "resin-connectable"
RDEPENDS_${PN}.remove = "resin-provisioner"
